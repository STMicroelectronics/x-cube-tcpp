<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DRP1M1_Sink_PPS.ewp</path>
  </project>
  <batchBuild />
</workspace>
