# IAR project TCPP01_Consumer_PPS.ewp, settings and files
configuration NUCLEO-G071RB_TCPP01_Consumer_PPS (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G071xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; _RTOS; USBPD_PORT_COUNT=1; _SNK; USBPDCORE_LIB_PD3_CONFIG_1; _TRACE; _GUI_INTERFACE; NUCLEO_MB1360A; USBPDM1_VCC_FEATURE_ENABLED; USBPDM1_DB_OUT_FEATURE_ENABLED; __DEBUG_CAD
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32G0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\..\Utilities\TRACER_EMB; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32G0XX\inc; ..\..\..\..\..\..\Utilities\GUI_INTERFACE; ..\..\..\..\..\..\Drivers\BSP\P-NUCLEO-USBPDM1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: TCPP01_Consumer_PPS.bin
  ILINK.IlinkOutputFile: TCPP01_Consumer_PPS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_it.c usbpd.c usbpd_dpm_user.c usbpd_pwr_if.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/BSP/x-nucleo-usbpdm1
    ../../../../../../Drivers/BSP/P-NUCLEO-USBPDM1/: usbpdm1_usbpd_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_comp.c stm32g0xx_hal_cortex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_rcc.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_dpm_core.c usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_CONFIG_1_CM0PLUS_wc32.a
  group Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Utilities/GUI_INTERFACE
    ../../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c data_struct_tlv.c gui_api.c
  group Utilities/TRACER_EMB
    ../../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
