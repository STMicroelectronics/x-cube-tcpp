<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SNK1M1_Sink.ewp</path>
  </project>
  <batchBuild />
</workspace>
