# IAR project USBPDM1_Consumer_LPM.ewp, settings and files
configuration USBPDM1_Consumer_LPM (ARM, debug)
  General.OGChipSelectEditMenu: STM32G081RB ST STM32G081RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_STM32G0XX_NUCLEO; NUCLEO_MB1360A; USBPDM1_DB_OUT_FEATURE_ENABLED; USBPDM1_VCC_FEATURE_ENABLED; USE_FULL_LL_DRIVER; USBPD_PORT_COUNT=1; _RTOS; _SNK; _TRACE; USBPDCORE_LIB_PD3_FULL; USE_HAL_DRIVER; STM32G081xx; _LOW_POWER
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/GUI_INTERFACE; ../../../../../../Utilities/TRACER_EMB; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/timer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: USBPDM1_Consumer_LPM.bin
  ILINK.IlinkOutputFile: USBPDM1_Consumer_LPM.out
  ILINK.IlinkIcfFile: stm32g081xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g081xx.s
  group Application/User
    ../Src/: adc.c app_freertos.c dma.c gpio.c main.c rtc.c stm32_lpm_if.c stm32_timer_if.c stm32g0xx_hal_msp.c stm32g0xx_it.c ucpd.c usart.c usbpd.c usbpd_dpm_core.c usbpd_dpm_user.c usbpd_lowpower.c usbpd_pwr_if.c usbpd_pwr_user.c usbpd_vdm_user.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/X-NUCLEO-USBPDM1
    ../../../../../../Drivers/BSP/X-NUCLEO-USBPDM1/: usbpdm1_usbpd_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_rcc.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Middlewares/USBPD
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM0PLUS_wc32.a
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
