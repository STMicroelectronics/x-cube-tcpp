<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USBPDM1_Consumer_LPM.ewp</path>
  </project>
  <batchBuild />
</workspace>
