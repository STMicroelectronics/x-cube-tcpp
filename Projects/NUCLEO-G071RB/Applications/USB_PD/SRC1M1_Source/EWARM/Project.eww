<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SRC1M1_Source.ewp</path>
  </project>
  <batchBuild />
</workspace>
