<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DRP1M1_DRP_LPM.ewp</path>
  </project>
  <batchBuild />
</workspace>
