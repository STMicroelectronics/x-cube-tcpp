<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SRC1M1_Source_TypeC_Only.ewp</path>
  </project>
  <batchBuild />
</workspace>
